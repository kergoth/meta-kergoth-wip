AUTO_DEPEND_TYPES_remove = "pkg-config"
