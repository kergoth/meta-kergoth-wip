do_install_append_feature-example-1 () {
    touch ${D}/example-1
}
