RDEPENDS_${PN}_remove_libc-musl = "nativesdk-pseudo nativesdk-qemu nativesdk-qemu-helper"
