NATIVESDKLIBC ?= "libc-glibc"
LIBCOVERRIDE = ":${NATIVESDKLIBC}"
TOOLCHAIN_HOST_TASK_remove_libc-musl = "nativesdk-libnss-nis"
