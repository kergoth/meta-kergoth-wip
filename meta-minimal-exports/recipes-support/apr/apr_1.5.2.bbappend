do_compile[exports] += "${BUILD_EXPORTS}"
