do_install[exports] += "${TARGET_PATH_EXPORTS}"
