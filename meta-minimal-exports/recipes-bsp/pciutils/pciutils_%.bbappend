export LIBDIR = "${libdir}"
