do_configure[exports] += "${BUILD_EXPORTS}"
