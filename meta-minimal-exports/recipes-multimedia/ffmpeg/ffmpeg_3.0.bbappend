EXTRA_OECONF += "\
  --prefix=${prefix} \
  --bindir=${bindir} \
  --docdir=${docdir}/ffmpeg \
  --incdir=${includedir} \
  --mandir=${mandir} \
"
