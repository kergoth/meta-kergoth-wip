EXTRA_OEMAKE += "'base_libdir=/${baselib}'"
