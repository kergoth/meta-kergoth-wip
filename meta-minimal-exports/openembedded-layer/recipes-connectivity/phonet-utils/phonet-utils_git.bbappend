EXTRA_OEMAKE = "\
    'CC=${CC}' \
    'CFLAGS=${CFLAGS}' \
    'prefix=${prefix}' \
    'libdir=${libdir}' \
    'sbindir=${sbindir}' \
    'sysconfdir=${sysconfdir}' \
"
