FILESEXTRAPATHS_prepend_virtclass-named-config-minimal := "${THISDIR}/busybox-minimal:"
PACKAGECONFIG_virtclass-named-config-minimal = ""
BBCLASSEXTEND += "named-config:minimal"
