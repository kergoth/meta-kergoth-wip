AUTO_PYTHON_PROVIDES_EXTRA += "\
    python-core:__builtin__ \
    python-core:os.path \
    python-core:sys \
"
