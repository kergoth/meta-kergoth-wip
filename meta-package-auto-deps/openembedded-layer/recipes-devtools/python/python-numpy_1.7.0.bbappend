AUTO_PYTHON_DEPENDS_EXCLUDE += "python-numpy:compat"
